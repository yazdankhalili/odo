# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: Main; Standard Peripheral Driver; STM32 Core; Delay; CAN; lcd16x2; SMT172; IO; SPI L9826; K Line; $PROJ_DIR$GLCD128x64; lcd20x4; lcd16x2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test.hex
  ILINK.IlinkOutputFile: Test.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CAN
    CAN/: CAN_Receive.c CAN_Receive.h CAN_Transmit.c CAN_Transmit.h
  group Delay
    Delay/: delay.c delay.h
  group GLCD128x64
    GLCD128x64/: GLCD128x64.c GLCD128x64.h
  group IO
    IO/: IO.c IO.h IO_Manager.c IO_Manager.h
  group K Line
    K Line/: K_Line.c K_Line.h
  group lcd16x2
    lcd16x2/: lcd16x2.c lcd16x2.h
  group lcd20x4
    lcd20x4/: lcd20x4.c lcd20x4.h
  group Main
    Main/: interrupts_manager.c interrupts_manager.h main.c main.h
  group SMT172
    SMT172/: SMT172.c SMT172.h
  group SPI L9826
    SPI L9826/: SPI_L9826.c SPI_L9826.h
  group Standard Peripheral Driver
    Standard Peripheral Driver/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_conf.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group STM32 Core
    STM32 Core/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
